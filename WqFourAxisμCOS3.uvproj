# Keil uVision project WqFourAxisμCOS3.uvproj, settings and files
target WqFourAxiμCOS3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WqFourAxis +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Core;.\Hardware\inc;.\Libraries\inc;.\Control\inc;.\App\inc;.\System\delay;.\System\sys;.\System\usart;..\WqFourAxisμCOS3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/src/: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ./Hardware/src/: battery_voltage.c led.c motor.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_md.s
