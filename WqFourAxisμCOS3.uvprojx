# Keil uVision project WqFourAxisμCOS3.uvprojx, settings and files
target WqFourAxiμCOS3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WqFourAxisμCOS3 +hex
  c flags: Optim=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\UCOSIII\uC-BSP;.\UCOSIII\uC-CFG;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III\Ports;.\UCOSIII\uCOS-III\Source;.\App\inc;.\Control\inc;.\Core;.\Hardware\inc;.\Libraries\inc;.\System\delay;.\System\sys;.\System\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/src/: aid_control.c data_pc.c flash_memory.c imu.c main.c stm32f10x_it.c system_stm32f10x.c remote_control.c task_app.c
  group Control
    ./Control/src/: control.c
  group Hardware
    ./Hardware/src/: battery_voltage.c eeprom.c iic.c led.c motor.c mpu6050.c ms5611.c timer.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_tim.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_md.s
  group uC-BSP
    ./UCOSIII/uC-BSP/: bsp.c bsp.h
  group uC-CFG
    ./UCOSIII/uC-CFG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC-CPU
    ./UCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_mem_a.asm lib_str.c
  group uC-PORT
    ./UCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC-SOURCE
    ./UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Readme
    ./: README.TXT
